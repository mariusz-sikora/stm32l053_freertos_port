# Keil uVision project firmware.uvprojx, settings and files
target stm32l053 (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: firmware
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group apps
    ./Source/: main.c
  group os
    ./Source/os/: list.c queue.c tasks.c
    ./Source/os/portable/MemMang/: heap_1.c
    ./Source/os/portable/RVDS/ARM_CM0/: port.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
